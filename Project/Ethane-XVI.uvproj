# Keil uVision project Ethane-XVI.uvproj, settings and files
target ETH (MCS-51)
  device: CH549 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FFF)  IROM(0-0x3FFF) CLOCK(56000000)
  output: Ethane-XVI +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User;..\User\Alkane;..\Libraries\Public;..\Libraries\GPIO;..\Libraries\ADC;..\Libraries\PWM;..\Libraries\FlashRom;..\Libraries\Timer
  link misc: REMOVEUNUSED
  group Libraries
    ../Libraries/Public/: DEBUG.C
    ../Libraries/GPIO/: GPIO.C
    ../Libraries/ADC/: ADC.C
    ../Libraries/FlashRom/: FlashRom.C
    ../Libraries/PWM/: PWM.C
    ../Libraries/Timer/: Timer.C
  group User
    ../User/: main.c CompositeHID.c BasicIO.c RgbDrv.c ParaConfig.c Diag.c
  group Alkane
    ../User/Alkane/: ALK_Func.c ALK_Rgb.c ALK_If.c
